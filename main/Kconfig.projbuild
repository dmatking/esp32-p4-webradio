## main/Kconfig.projbuild
```kconfig
menu "P4 Radio"

config WIFI_TZ
    string "POSIX timezone string"
    default "CST6CDT,M3.2.0,M11.1.0"

endmenu
```
